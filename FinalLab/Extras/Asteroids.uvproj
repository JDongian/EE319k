# Keil uVision project Asteroids.uvproj, settings and files
target Lab9 (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab9
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s PLL.c rit128x96x4.c Delay.c Main.c SysTickInts.c Output.c Sound.c DAC.c Game.c ADC.c Control.c Timer.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
  group DrawLib
    ./drawLib/: draw2D.c graphicsUtil.c math2.c
