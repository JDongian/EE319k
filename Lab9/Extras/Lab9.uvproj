# Keil uVision project Lab9.uvproj, settings and files
target PeriodicSysTickInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab8
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: ADC.c Delay.c Main.c PLL.c SysTickInts.c ADC.h Delay.h globals.h hw_types.h LCD.h lm3s1968.h Main.h PLL.h SysTickInts.h LCD.s Startup.s UART.c UART.h FIFO.c FIFO.h
